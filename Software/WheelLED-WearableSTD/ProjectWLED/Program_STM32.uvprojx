# Keil uVision project Program_STM32.uvprojx, settings and files
target STM32F030F (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F030F
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX, ARM_MATH_CM0
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../Libraries/CMSIS/Device/: startup_stm32f030.s system_stm32f0xx.c
  group Library
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_gpio.c stm32f0xx_usart.c stm32f0xx_spi.c
    ../Program/: stm32f0xx_conf.h
  group Driver
    ../Program/drivers/: stm32f0_delay.c stm32f0_usart.c stm32f0_spi.c
  group Program
    ../Program/: main.c wheelled_wearable.c wheelled_wearable_bsp.c wheelled_wearable_it.c
  group Module
    ../Program/modules/: module_mpu6500.c module_wheelled_bt.c
  group Algorithm
    ../Program/algorithms/: algorithm_moveAve.c
