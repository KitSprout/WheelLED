# Keil uVision project Program_STM32.uvprojx, settings and files
target STM32F031F (ARM-ADS)
  device: STM32F031F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F031F +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\Program;..\Program\Dirvers;..\Program\Modules;..\Program\Algorithms;.\RTE;.\RTE\Device\STM32F030F4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Library
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_misc.c stm32f0xx_dma.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_gpio.c stm32f0xx_usart.c
    ../Program/: stm32f0xx_conf.h
  group Driver
    ../Program/Dirvers/: stm32f0_delay.c
  group Program
    ../Program/: main.c wheelLED.c wheelLED_it.c
target addr_01 (ARM-ADS)
  device: STM32F031F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: STM32F031F +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,YD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 4.1.0, Device:Startup 1.5.0
